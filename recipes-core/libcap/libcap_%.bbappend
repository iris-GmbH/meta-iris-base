# add proper SPDX license identifier
LICENSE = "BSD-3-Clause | GPLv2"
