# SPDX-License-Identifier: MIT
# Copyright (C) 2022 iris-GmbH infrared & intelligent sensors

PACKAGECONFIG_append = " --with-cryptsetup"
