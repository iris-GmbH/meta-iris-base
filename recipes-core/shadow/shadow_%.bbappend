# add proper SPDX license identifier
LICENSE = "BSD-3-Clause | Artistic-1.0"
