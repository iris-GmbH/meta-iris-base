# SPDX-License-Identifier: MIT
# Copyright (C) 2024 iris-GmbH infrared & intelligent sensors

RESCUE_NAME = "irma-initramfs"
require irma-fit.inc
