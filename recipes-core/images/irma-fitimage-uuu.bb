# SPDX-License-Identifier: MIT
# Copyright (C) 2024 iris-GmbH infrared & intelligent sensors

RESCUE_NAME = "fsl-image-mfgtool-initramfs"
require irma-fit.inc
