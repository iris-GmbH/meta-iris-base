# remove unnecessary BerkeleyDB support in perl
PACKAGECONFIG_remove = "bdb"
