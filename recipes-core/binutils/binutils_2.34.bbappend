# these CVEs where introduced in binutils 2.35
CVE_CHECK_WHITELIST += "CVE-2020-16590 CVE-2020-16591 CVE-2020-16593 CVE-2020-16599 CVE-2021-20294"
