# The bug described in this CVE only affects the code generation process in
# flex, not the generated code itself. It is therefore harmless:
# https://github.com/NixOS/nixpkgs/issues/55386#issuecomment-683792976
CVE_CHECK_WHITELIST += "CVE-2019-6293"
