FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-yaml-cpp-Fix-CVEs.patch"
