RDEPENDS:${PN} += "${PYTHON_PN}-multiprocessing"
