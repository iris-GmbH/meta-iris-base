SRCBRANCH ?= "master"
SRCREV = "d7b343fd262880994f041ce2335442e7bd1071f5"

SRC_URI = "git://git.kernel.org/pub/scm/utils/mmc/mmc-utils.git;branch=${SRCBRANCH}"
