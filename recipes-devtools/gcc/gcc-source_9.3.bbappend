# SPDX-License-Identifier: MIT
# Copyright (C) 2021 iris-GmbH infrared & intelligent sensors

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-libstdc-Fix-create_directories-to-resolve-symlinks-P.patch"
