PACKAGECONFIG_append = " http-auth-request"
