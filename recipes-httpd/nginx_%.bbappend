# enable auth request module
PACKAGECONFIG += "http-auth-request"
