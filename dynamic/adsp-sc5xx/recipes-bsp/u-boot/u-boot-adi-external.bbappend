# set fixed srcrev for offline builds
SRCREV = "c372d6caddd5945952822e5a619493fdb74a6410"
