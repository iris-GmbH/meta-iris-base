# SPDX-License-Identifier: MIT
# Copyright (C) 2022 iris-GmbH infrared & intelligent sensors

# use recipe from meta-secure-imx as base
require irma6-initramfs.inc

INITSCRIPT_PACKAGE = "irma6-initrdscripts-init"

