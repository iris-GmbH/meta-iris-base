# SPDX-License-Identifier: MIT
# Copyright (C) 2025 iris-GmbH infrared & intelligent sensors

# Adjust keyblob location - this is fixed and cannot be changed during runtime
# Use "/" to allow absolute paths to anywhere
EXTRA_OEMAKE = "KEYBLOB_LOCATION=/"
