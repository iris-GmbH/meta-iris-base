# SPDX-License-Identifier: MIT
# Copyright (C) 2022 iris-GmbH infrared & intelligent sensors

require firmwarezip.inc

FIRMWAREZIP_BOOTLOADER_NAME_sc573-gen6-4dvein = "u-boot-sc573-gen6.ldr"

