LICENSE = "BSD-3-Clause & OpenSSL & hidapi"
LIC_FILES_CHKSUM = "file://${S}/LICENSE.bsd3;md5=1fbcd66ae51447aa94da10cbf6271530 \
                    file://${S}/LICENSE.openssl;md5=06698624268f7be8151210879bbcbcab \
                    file://${S}/LICENSE.hidapi;md5=e0ea014f523f64f0adb13409055ee59e"

SRC_URI = "https://iris-devops-imx-cst-public-693612562064.s3.eu-central-1.amazonaws.com/cst-3.3.1.tgz"
SRC_URI[sha256sum] = "1efdddda50cf36bc1e48d78a9601ba33db0cc2203ff1086c4b373f94b9366464"
