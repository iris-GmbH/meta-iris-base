# SPDX-License-Identifier: MIT
# Copyright (C) 2022 iris-GmbH infrared & intelligent sensors

require irma6-swuimage.inc

SWU_DEVTREE_imx8mpevk = "imx8mp-evk.dtb"
SWU_TARGET_DEVTREE_imx8mpevk = "imx8mp-evk.dtb"

