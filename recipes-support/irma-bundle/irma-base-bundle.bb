# SPDX-License-Identifier: MIT
# Copyright (C) 2023 iris-GmbH infrared & intelligent sensors

require recipes-support/irma-bundle/irma-bundle.inc
