# Overrides for HAB and AHAB
OVERRIDES:append:mx8m-generic-bsp = ":hab4"
OVERRIDES:append:mx9-generic-bsp = ":ahab"
